# Keil uVision project Crazepony.uvproj, settings and files
target Crazepony (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Crazepony +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,RX6
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver\BMP085;.\HardWareDriver\C;.\HardWareDriver\H;.\Control\C;.\Control\H;.\FATFS_V0.08A\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardWareDriver
    ./HardWareDriver/C/: delay.c Led.c MPU6050.c Tim.c stmflash.c UART1.c DMP.c ms5611_I2C.c IICx.c HMC5883L.c SPI_MSD_Driver.c sdcard.c SPI.c DW1000.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c Sys_Fun.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_pwr.c stm32f10x_sdio.c stm32f10x_exti.c
  group Control
    ./Control/C/: Control.c
  group FATFS_V0.08A
    ./FATFS_V0.08A/src/: diskio.c ff.c
